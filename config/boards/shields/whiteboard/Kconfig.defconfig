## config/boards/shields/whiteboard/Kconfig.defconfig
```kconfig
if SHIELD_WHITEBOARD

config ZMK_KEYBOARD_NAME
    default "Nya~ ♡(UwU✿)"

endif
```
